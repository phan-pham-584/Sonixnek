# Keil uVision project SN32F407_clock.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: SN32F407F SONiX
  pack: SONiX.SN32F4_DFP.1.1.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x7FFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SN32F407_clock +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Source\Driver;.\Source\Module
  memory RVCT4: ROM 0x0 size 0x7ffc
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./: main.c
  group Driver
    ./Source/Driver/: PFPA.c SysTick.c GPIO.c CT16B0.c CT16B1.c I2C0.c Utility.c WDT.c
  group Module
    ./Source/Module/: Buzzer.c EEPROM.c Segment.c KeyScan.c
  group Readme
    ./Source/Readme/: readme.txt
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.1
